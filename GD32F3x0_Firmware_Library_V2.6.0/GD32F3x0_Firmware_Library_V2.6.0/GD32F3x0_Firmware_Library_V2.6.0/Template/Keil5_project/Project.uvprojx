# Keil uVision project Project.uvprojx, settings and files
target GD32F310 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F310C8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.4.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf.exe --bin --output .\output\Project.bin .\output\Project.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F310
  c include: ..\..\Firmware\CMSIS\GD\GD32F3x0\Include;..\..\Utilities;..\..\Firmware\CMSIS;..\..\Template;..\..\Firmware\CMSIS\GD\GD32F3x0\Source\ARM;..\..\Firmware\GD32F3x0_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../: gd32f3x0_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
  group Peripherals
    ../../Firmware/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group Utilities
    ../../Utilities/: gd32f350r_eval.c
  group Doc
    ../: readme.txt
target GD32F330 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F330F8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.4.0
  cpu: as above
  output: Project +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F330
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
target GD32F350 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F330F8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.4.0
  cpu: as above
  output: Project +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F350
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
target GD32F355 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F355RB GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.4.0
  cpu: IRAM(0x20000000,0x04000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F355
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target GD32F370 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F370RB GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.4.0
  cpu: as above
  output: Project +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F370
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
